# Keil uVision project USER.uvproj, settings and files
target 51程序 (MCS-51)
  device: STC12C5A60S2 STC12C5A16S2 Series
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0xEFFF) CLOCK(45000000) MODP2
  output: RV +hex
  c flags: Optimize=8 SizeSpeed=1
  group LCD
    ./SOURCES/: STARTUP.A51 main.c lcd.c sys.c
